options:
  parameters:
    author: ghostop14
    generate_options: no_gui
    id: ata_12ant_xcorr
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: ATA 12 Antenna XEngine
  states: {}

blocks:
- name: ending_channel
  id: variable
  parameters:
    comment: This is calc as start+num_channels
    value: starting_channel+num_channels-1
  states: {}
- name: file_timestamp
  id: variable
  parameters:
    value: now.strftime("%Y_%m_%d_%H_%M")
  states: {}
- name: now
  id: variable
  parameters:
    value: datetime.now()
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '256'
  states: {}
- name: output_file
  id: variable
  parameters:
    value: '''/home/mpiscopo/xengine_output/staging/ata_'' + file_timestamp'
  states: {}
- name: starting_channel
  id: variable
  parameters:
    value: '1920'
  states: {}
- name: ata_snap_source_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_2_ant_1f.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10000'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_5_ant_2a.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10001'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10002'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10003'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10005'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10004'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_1
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10006'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_1_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10007'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_1_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10008'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_1_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10009'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_1_0_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10010'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_1_0_0_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10011'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: clenabled_clXEngine_0
  id: clenabled_clXEngine
  parameters:
    antenna_list: 1a,1f,4g,5c,1c,2b,2h,1h,1k,4j,2a,3c
    channel_width: '250000.0'
    deviceId: '0'
    devices: '1'
    disable_output: 'False'
    file_base: output_file
    first_channel: starting_channel
    integration: '10000'
    internal_synchronizer: 'True'
    num_channels: num_channels
    num_inputs: '12'
    object_name: CasA
    openCLPlatform: '1'
    output_file: 'True'
    platformId: '0'
    polarization: '2'
    rollover_size_mb: '0'
    setDebug: 'False'
    starting_chan_center_freq: '2968000000.0'
    sync_timestamp: '0'
    type: Packed XY
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: note_0
  id: note
  parameters:
    comment: These should be configured
  states: {}

connections:
- [ata_snap_source_0, '0', clenabled_clXEngine_0, '0']
- [ata_snap_source_0_0, '0', clenabled_clXEngine_0, '1']
- [ata_snap_source_0_0_0, '0', clenabled_clXEngine_0, '2']
- [ata_snap_source_0_0_0_0, '0', clenabled_clXEngine_0, '3']
- [ata_snap_source_0_0_0_0_0, '0', clenabled_clXEngine_0, '5']
- [ata_snap_source_0_0_0_0_0_0, '0', clenabled_clXEngine_0, '4']
- [ata_snap_source_0_0_0_0_0_1, '0', clenabled_clXEngine_0, '6']
- [ata_snap_source_0_0_0_0_0_1_0, '0', clenabled_clXEngine_0, '7']
- [ata_snap_source_0_0_0_0_0_1_0_0, '0', clenabled_clXEngine_0, '8']
- [ata_snap_source_0_0_0_0_0_1_0_0_0, '0', clenabled_clXEngine_0, '9']
- [ata_snap_source_0_0_0_0_0_1_0_0_0_0, '0', clenabled_clXEngine_0, '10']
- [ata_snap_source_0_0_0_0_0_1_0_0_0_0_0, '0', clenabled_clXEngine_0, '11']
- [clenabled_clXEngine_0, sync, ata_snap_source_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_1, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_1_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_1_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_1_0_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_1_0_0_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_1_0_0_0_0_0, sync]

metadata:
  file_format: 1
