options:
  parameters:
    author: ghostop14
    generate_options: no_gui
    id: ata_12ant_xcorr
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: ATA 12 Antenna XEngine
  states: {}

blocks:
- name: center_channel
  id: variable
  parameters:
    value: starting_channel + num_channels/2
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: sky_freq + (center_channel-2048)*channel_width
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: data_vector_len
  id: variable
  parameters:
    value: int(snap_vector_len/2)
  states: {}
- name: ending_channel
  id: variable
  parameters:
    value: starting_channel+num_channels-1
  states: {}
- name: file_timestamp
  id: variable
  parameters:
    value: now.strftime("%Y_%m_%d_%H_%M")
  states: {}
- name: gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: half_channel_width
  id: variable
  parameters:
    value: channel_width/2.0
  states: {}
- name: now
  id: variable
  parameters:
    value: datetime.now()
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '256'
  states: {}
- name: output_file
  id: variable
  parameters:
    value: '''/home/mpiscopo/xengine_output/staging/ata_'' + file_timestamp'
  states: {}
- name: sky_freq
  id: variable
  parameters:
    value: 3000e6
  states: {}
- name: snap_bandwidth
  id: variable
  parameters:
    value: channel_width*num_channels
  states: {}
- name: snap_samp_rate
  id: variable
  parameters:
    value: num_channels/4e-6
  states: {}
- name: snap_vector_len
  id: variable
  parameters:
    value: int((ending_channel-starting_channel+1)*2)
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: sky_freq - (2048-starting_channel)*channel_width
  states: {}
- name: starting_channel
  id: variable
  parameters:
    value: '1920'
  states: {}
- name: ata_snap_source_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_2_ant_1f.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10000'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_5_ant_2a.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10001'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10002'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10003'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10005'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10004'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_1
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10006'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_1_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10007'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_1_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10008'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_1_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10009'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_1_0_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10010'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0_0_0_1_0_0_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap_feb9/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10011'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: clenabled_clXEngine_0
  id: clenabled_clXEngine
  parameters:
    deviceId: '0'
    devices: '1'
    file_base: output_file
    first_channel: starting_channel
    integration: '10000'
    internal_synchronizer: 'True'
    num_channels: num_channels
    num_inputs: '12'
    openCLPlatform: '1'
    output_file: 'True'
    platformId: '0'
    polarization: '2'
    rollover_size_mb: '0'
    setDebug: 'False'
    type: Packed XY
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: note_0
  id: note
  parameters:
    comment: These should be configured
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: These are calculated
  states: {}

connections:
- [ata_snap_source_0, '0', clenabled_clXEngine_0, '0']
- [ata_snap_source_0_0, '0', clenabled_clXEngine_0, '1']
- [ata_snap_source_0_0_0, '0', clenabled_clXEngine_0, '2']
- [ata_snap_source_0_0_0_0, '0', clenabled_clXEngine_0, '3']
- [ata_snap_source_0_0_0_0_0, '0', clenabled_clXEngine_0, '5']
- [ata_snap_source_0_0_0_0_0_0, '0', clenabled_clXEngine_0, '4']
- [ata_snap_source_0_0_0_0_0_1, '0', clenabled_clXEngine_0, '6']
- [ata_snap_source_0_0_0_0_0_1_0, '0', clenabled_clXEngine_0, '7']
- [ata_snap_source_0_0_0_0_0_1_0_0, '0', clenabled_clXEngine_0, '8']
- [ata_snap_source_0_0_0_0_0_1_0_0_0, '0', clenabled_clXEngine_0, '9']
- [ata_snap_source_0_0_0_0_0_1_0_0_0_0, '0', clenabled_clXEngine_0, '10']
- [ata_snap_source_0_0_0_0_0_1_0_0_0_0_0, '0', clenabled_clXEngine_0, '11']
- [clenabled_clXEngine_0, sync, ata_snap_source_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_1, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_1_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_1_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_1_0_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_1_0_0_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0_0_0_1_0_0_0_0_0, sync]

metadata:
  file_format: 1
