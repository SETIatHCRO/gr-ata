options:
  parameters:
    author: ghostop14
    generate_options: no_gui
    id: snap_correlation_test_3ant_synch_in_xengine
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: ATA New SNAP X-Engine
  states: {}

blocks:
- name: ending_channel
  id: variable
  parameters:
    value: starting_channel+num_channels-1
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '256'
  states: {}
- name: starting_channel
  id: variable
  parameters:
    value: '1920'
  states: {}
- name: ata_snap_source_0
  id: ata_snap_source
  parameters:
    data_source: '3'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap/snap_2_ant_1f.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10000'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0
  id: ata_snap_source
  parameters:
    data_source: '3'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap/snap_7_ant_3c.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10001'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: ata_snap_source_0_0_0
  id: ata_snap_source
  parameters:
    data_source: '3'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap/snap_8_ant_4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'True'
    port: '10002'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: clenabled_clXEngine_0
  id: clenabled_clXEngine
  parameters:
    affinity: '[0,1]'
    antenna_list: 1f,3c,4g
    channel_width: '25000.0'
    deviceId: '0'
    devices: '1'
    disable_output: 'False'
    file_base: /home/mpiscopo/xengine_output/2021_Jan_04/casa_2021_jan_04_sync_v3_xeng
    first_channel: starting_channel
    integration: '1024'
    internal_synchronizer: 'True'
    num_channels: num_channels
    num_inputs: '3'
    object_name: CasA
    openCLPlatform: '1'
    output_file: 'True'
    platformId: '0'
    polarization: '2'
    rollover_size_mb: '0'
    setDebug: 'False'
    starting_chan_center_freq: '2968000000.0'
    sync_timestamp: '0'
    type: Packed XY
  states: {}
- name: note_0
  id: note
  parameters:
    comment: These should be configured
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: These are calculated
  states: {}

connections:
- [ata_snap_source_0, '0', clenabled_clXEngine_0, '0']
- [ata_snap_source_0_0, '0', clenabled_clXEngine_0, '1']
- [ata_snap_source_0_0_0, '0', clenabled_clXEngine_0, '2']
- [clenabled_clXEngine_0, sync, ata_snap_source_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0, sync]
- [clenabled_clXEngine_0, sync, ata_snap_source_0_0_0, sync]

metadata:
  file_format: 1
