options:
  parameters:
    author: ghostop14
    generate_options: qt_gui
    id: resend_pcap
    output_language: python
    title: Resend PCAP
  states: {}

blocks:
- name: channel_samp_rate
  id: variable
  parameters:
    value: snap_samp_rate*(num_channels/4096)
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: snap_samp_rate
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: target_system
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: 500.0*2
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: channel_samp_rate
    type: byte
  states: {state: bypassed}
- name: grnet_pcap_udp_source_0
  id: grnet_pcap_udp_source
  parameters:
    file: /opt/tmp/ata/goes17_volt_synced.pcap
    header: '0'
    notifyMissed: 'False'
    payloadsize: '8200'
    port: '4030'
    repeatFile: 'True'
    type: byte
  states: {}
- name: grnet_udp_sink_0
  id: grnet_udp_sink
  parameters:
    addr: target_system
    header: '0'
    payloadsize: '8200'
    port: '4030'
    send_eof: 'False'
    type: byte
    vlen: '1'
  states: {}
- name: grnet_udp_sink_0_0
  id: grnet_udp_sink
  parameters:
    addr: target_system
    header: '0'
    payloadsize: '8200'
    port: '4031'
    send_eof: 'False'
    type: byte
    vlen: '1'
  states: {state: disabled}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', blocks_probe_rate_0, '0']
- [blocks_throttle_0, '0', grnet_udp_sink_0, '0']
- [grnet_pcap_udp_source_0, '0', blocks_throttle_0, '0']
- [grnet_pcap_udp_source_0, '0', grnet_udp_sink_0_0, '0']

metadata:
  file_format: 1
