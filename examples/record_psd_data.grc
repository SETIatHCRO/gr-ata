options:
  parameters:
    generate_options: qt_gui
    id: usrp_2chrx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: fftsize
  id: variable
  parameters:
    comment: center frequency for voyager file
    value: 8192*2
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fftsize
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: decimation
    type: float
    vlen: fftsize
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-30'
    n: '10'
    vlen: fftsize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftsize
    type: complex
  states: {}
- name: fc
  id: parameter
  parameters:
    label: carrier frequency
    short_id: c
    type: eng_float
    value: 629e6
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fftsize)
  states: {}
- name: file_channel_0
  id: blocks_file_sink
  parameters:
    file: src_name+'_'+timestamp+'.dat'
    type: float
    vlen: fftsize
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '23'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: fftsize
    x_axis_label: '"Freq"'
    x_start: 1600 - (samp_rate/2)
    x_step: samp_rate/fftsize
    y_axis_label: '"PSD"'
    ymax: '70'
    ymin: '50'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 50e6
  states: {}
- name: src_name
  id: parameter
  parameters:
    type: str
    value: 2350+646
  states: {}
- name: timestamp
  id: parameter
  parameters:
    type: str
    value: str(datetime.now())
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: fc
    clock_rate: '0.0'
    clock_source0: internal
    dc_offs_enb0: 'False'
    dev_addr: '"serial=31D3A48"'
    dev_args: '""'
    gain0: gaindB
    iq_imbal_enb0: 'False'
    norm_gain0: 'False'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', file_channel_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source, '0', blocks_conjugate_cc_0, '0']

metadata:
  file_format: 1
