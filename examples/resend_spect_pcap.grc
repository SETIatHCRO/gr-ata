options:
  parameters:
    author: ghostop14
    generate_options: qt_gui
    id: resend_spect_pcap
    output_language: python
    title: Resend Spectrometer PCAP
  states: {}

blocks:
- name: channel_samp_rate
  id: variable
  parameters:
    value: snap_samp_rate
  states: {}
- name: snap_samp_rate
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: channel_samp_rate
    type: byte
  states: {state: bypassed}
- name: grnet_pcap_udp_source_0
  id: grnet_pcap_udp_source
  parameters:
    file: /opt/tmp/ata/spec_mode.pcap
    header: '0'
    notifyMissed: 'False'
    payloadsize: '8200'
    port: '4022'
    repeatFile: 'True'
    type: byte
  states: {}
- name: grnet_udp_sink_0
  id: grnet_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '8200'
    port: '4022'
    send_eof: 'False'
    type: byte
    vlen: '1'
  states: {}

connections:
- [blocks_throttle_0, '0', grnet_udp_sink_0, '0']
- [grnet_pcap_udp_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
