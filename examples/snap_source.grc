options:
  parameters:
    author: ghostop14
    generate_options: qt_gui
    id: ata_snap_source
    output_language: python
    title: ATA New SNAP Source
  states: {}

blocks:
- name: center_channel
  id: variable
  parameters:
    value: starting_channel + num_channels/2
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: sky_freq + (center_channel-2048)*channel_width
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: data_vector_len
  id: variable
  parameters:
    value: int(snap_vector_len/2)
  states: {}
- name: ending_channel
  id: variable
  parameters:
    value: starting_channel+num_channels-1
  states: {}
- name: gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: half_channel_width
  id: variable
  parameters:
    value: channel_width/2.0
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: sky_freq
  id: variable
  parameters:
    value: 1690e6
  states: {}
- name: snap_bandwidth
  id: variable
  parameters:
    value: channel_width*num_channels
  states: {}
- name: snap_samp_rate
  id: variable
  parameters:
    value: num_channels / 4e-6
  states: {}
- name: snap_vector_len
  id: variable
  parameters:
    value: int((ending_channel-starting_channel+1)*2)
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: sky_freq - (2048-starting_channel)*channel_width
  states: {}
- name: starting_channel
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: waterfall_min
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Waterfall Min
    orient: Qt.Horizontal
    start: '-100'
    step: '10'
    stop: '10'
    value: '-20'
  states: {}
- name: ata_snap_source_0
  id: ata_snap_source
  parameters:
    affinity: '0'
    data_source: '3'
    ending_channel: ending_channel
    file: /opt/tmp/ata/new_snap_format/4g.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'False'
    port: '10000'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: data_vector_len
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: data_vector_len
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '500'
    type: float
    vlen: data_vector_len
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '500'
    type: float
    vlen: data_vector_len
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: 500.0*2
    type: byte
    vlen: num_channels*2
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: data_vector_len
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: data_vector_len
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: data_vector_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: data_vector_len
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: 'Sequence # Source 0'
    type: byte
    vlen: snap_vector_len
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: snap_samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: snap_vector_len
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: snap_vector_len
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: data_vector_len
    type: complex
  states: {}
- name: clenabled_clFFT_0
  id: clenabled_clFFT
  parameters:
    deviceId: '0'
    devices: '1'
    fft_dir: '1'
    fft_size: data_vector_len
    num_streams: '1'
    openCLPlatform: '1'
    platformId: '0'
    setDebug: '0'
    shift: 'True'
    type: complex
    window: window.blackmanharris(data_vector_len)
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    affinity: '1'
    fft_size: data_vector_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(data_vector_len)
  states: {state: disabled}
- name: mesa_LongTermIntegrator_0
  id: mesa_LongTermIntegrator
  parameters:
    normalize: 'True'
    reset: 'False'
    vlength: data_vector_len
  states: {}
- name: mesa_LongTermIntegrator_0_0
  id: mesa_LongTermIntegrator
  parameters:
    normalize: 'True'
    reset: 'False'
    vlength: data_vector_len
  states: {}
- name: note_0
  id: note
  parameters:
    comment: These should be configured
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: These are calculated
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    gui_hint: 0,0,1,1
    label1: X pol
    label2: Y pol
    name: '"Streamed Vectors"'
    nconnections: '2'
    vlen: data_vector_len
    x_axis_label: Frequency
    x_start: start_freq
    x_step: channel_width
    x_units: Hz
    y_axis_label: Power
    ymax: '16'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    gui_hint: 3,0,1,1
    label1: x pol
    name: '"X Integration"'
    vlen: data_vector_len
    x_axis_label: Frequency
    x_start: start_freq
    x_step: channel_width
    x_units: Hz
    y_axis_label: Power
    ymax: '100'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_1_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    color1: '"red"'
    gui_hint: 4,0,1,1
    label1: y pol
    name: '"Y Integration"'
    vlen: data_vector_len
    x_axis_label: Frequency
    x_start: start_freq
    x_step: channel_width
    x_units: Hz
    y_axis_label: Power
    ymax: '100'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: snap_bandwidth
    fc: center_freq
    fftsize: data_vector_len
    gui_hint: 1,0,1,1
    int_max: '8'
    int_min: waterfall_min
    name: '"X pol spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [ata_snap_source_0, '0', blocks_probe_rate_0, '0']
- [ata_snap_source_0, '0', blocks_vector_to_stream_0, '0']
- [ata_snap_source_0, '1', blocks_tag_debug_0, '0']
- [ata_snap_source_0, '1', blocks_vector_to_stream_0_0, '0']
- [ata_snap_source_0, sync_header, blocks_message_debug_0, print]
- [blocks_complex_to_mag_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_integrate_xx_0, '0', mesa_LongTermIntegrator_0, '0']
- [blocks_integrate_xx_0_0, '0', mesa_LongTermIntegrator_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_stream_to_vector_1, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_stream_to_vector_1, '0', clenabled_clFFT_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_waterfall_sink_x_0, '0']
- [clenabled_clFFT_0, '0', blocks_vector_to_stream_1, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_1, '0']
- [mesa_LongTermIntegrator_0, '0', qtgui_vector_sink_f_0_1, '0']
- [mesa_LongTermIntegrator_0_0, '0', qtgui_vector_sink_f_0_1_0, '0']

metadata:
  file_format: 1
