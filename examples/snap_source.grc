options:
  parameters:
    author: ghostop14
    generate_options: qt_gui
    id: ata_snap_source
    output_language: python
    title: ATA New SNAP Source
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: ata_snap_source_0
  id: ata_snap_source
  parameters:
    header: '1'
    ipv6: 'False'
    notifyMissed: 'False'
    port: '4030'
    srcZeros: 'True'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '512'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '512'
    type: byte
  states: {}
- name: grnet_Signed8ToComplex_0
  id: grnet_Signed8ToComplex
  parameters: {}
  states: {}
- name: grnet_Signed8ToComplex_0_0
  id: grnet_Signed8ToComplex
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: X Polarization
    label2: Y Polarization
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-100'
  states: {}

connections:
- [ata_snap_source_0, '0', blocks_vector_to_stream_0, '0']
- [ata_snap_source_0, '1', blocks_vector_to_stream_0_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', grnet_Signed8ToComplex_0, '0']
- [blocks_vector_to_stream_0_0, '0', grnet_Signed8ToComplex_0_0, '0']
- [grnet_Signed8ToComplex_0, '0', blocks_throttle_0, '0']
- [grnet_Signed8ToComplex_0_0, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
