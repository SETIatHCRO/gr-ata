options:
  parameters:
    author: ghostop14
    generate_options: qt_gui
    id: ata_snap_source
    output_language: python
    title: ATA New SNAP Source
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2500e6
  states: {}
- name: ata_snap_source_0
  id: ata_snap_source
  parameters:
    header: '1'
    ipv6: 'False'
    notifyMissed: 'True'
    port: '50000'
    srcZeros: 'True'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: 1/127.0
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: 1/127.0
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: 1/127.0
  states: {}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: 1/127.0
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: X Polarization
    label2: Y Polarization
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-100'
  states: {}

connections:
- [ata_snap_source_0, '0', blocks_throttle_0, '0']
- [ata_snap_source_0, '1', blocks_char_to_float_0_0, '0']
- [ata_snap_source_0, '2', blocks_char_to_float_0_0_0, '0']
- [ata_snap_source_0, '3', blocks_char_to_float_0_0_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_char_to_float_0_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_throttle_0, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
