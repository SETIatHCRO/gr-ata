options:
  parameters:
    author: ghostop14
    generate_options: qt_gui
    id: ata_snap_spect_source
    output_language: python
    title: ATA New SNAP Source
  states: {}

blocks:
- name: center_channel
  id: variable
  parameters:
    value: starting_channel + num_channels/2
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: sky_freq + (center_channel-2048)*channel_width
  states: {}
- name: channel_samp_rate
  id: variable
  parameters:
    value: snap_samp_rate*(num_channels/4096)
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: snap_samp_rate/4096.0
  states: {}
- name: data_vector_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: ending_channel
  id: variable
  parameters:
    value: starting_channel+num_channels-1
  states: {}
- name: gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: half_channel_width
  id: variable
  parameters:
    value: channel_width/2.0
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: sky_freq
  id: variable
  parameters:
    value: 1690e6
  states: {}
- name: snap_samp_rate
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: sky_freq - (2048-starting_channel)*channel_width
  states: {}
- name: starting_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ata_snap_source_0
  id: ata_snap_source
  parameters:
    affinity: '0'
    ending_channel: ending_channel
    header: '2'
    ipv6: 'False'
    notifyMissed: 'True'
    port: '4022'
    srcZeros: 'True'
    starting_channel: starting_channel
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: data_vector_len
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: data_vector_len
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: data_vector_len
  states: {}
- name: blocks_nlog10_ff_0_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: data_vector_len
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: float
    vlen: data_vector_len
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: channel_samp_rate
    type: float
    vlen: data_vector_len
  states: {}
- name: note_0
  id: note
  parameters:
    comment: These should be configured
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: These are calculated
  states: {}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    gui_hint: 0,0,1,1
    label1: x pol
    name: '"XX Integration"'
    vlen: data_vector_len
    x_axis_label: Channel
    x_start: '0'
    x_step: '1'
    x_units: Hz
    y_axis_label: Power
    ymax: '-30'
    ymin: '-150'
  states: {}
- name: qtgui_vector_sink_f_0_1_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    color1: '"red"'
    gui_hint: 1,0,1,1
    label1: y pol
    name: '"YY Integration"'
    vlen: data_vector_len
    x_axis_label: Channel
    x_start: '0'
    x_step: '1'
    x_units: Hz
    y_axis_label: Power
    ymax: '-30'
    ymin: '-150'
  states: {}
- name: qtgui_vector_sink_f_0_1_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    color1: '"red"'
    gui_hint: 2,0,1,1
    label1: y pol
    name: '"XY Real Integration"'
    vlen: data_vector_len
    x_axis_label: Channel
    x_start: '0'
    x_step: '1'
    x_units: Hz
    y_axis_label: Power
    ymax: '-30'
    ymin: '-150'
  states: {}
- name: qtgui_vector_sink_f_0_1_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    color1: '"red"'
    gui_hint: 3,0,1,1
    label1: y pol
    name: '"XY Imag Integration"'
    vlen: data_vector_len
    x_axis_label: Channel
    x_start: '0'
    x_step: '1'
    x_units: Hz
    y_axis_label: Power
    ymax: '-30'
    ymin: '-150'
  states: {}

connections:
- [ata_snap_source_0, '0', blocks_probe_rate_0, '0']
- [ata_snap_source_0, '0', blocks_throttle_0, '0']
- [ata_snap_source_0, '1', blocks_nlog10_ff_0_0, '0']
- [ata_snap_source_0, '2', blocks_nlog10_ff_0_0_0, '0']
- [ata_snap_source_0, '3', blocks_nlog10_ff_0_0_0_0, '0']
- [ata_snap_source_0, sync_header, blocks_message_debug_0, print]
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0_1, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0_1_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_vector_sink_f_0_1_0_0, '0']
- [blocks_nlog10_ff_0_0_0_0, '0', qtgui_vector_sink_f_0_1_0_0_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_1, print]
- [blocks_throttle_0, '0', blocks_nlog10_ff_0, '0']

metadata:
  file_format: 1
