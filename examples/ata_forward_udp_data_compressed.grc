<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>forward_udp_data_compressed</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimatedrate</value></param>
<param><key>value</key><value>samp_rate/decimation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_frequency</value></param>
<param><key>value</key><value>629.1456e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>104.8576e6</value></param>
</block>
<block>
<key>ata_ata_stream</key>
<param><key>id</key><value>ata_ata_stream_0</value></param>
<param><key>comment</key><value>X Channel</value></param>
<param><key>header</key><value>5</value></param>
<param><key>notifyMissed</key><value>True</value></param>
<param><key>payloadsize</key><value>4160</value></param>
<param><key>port</key><value>50000</value></param>
</block>
<block>
<key>ata_ata_stream</key>
<param><key>id</key><value>ata_ata_stream_0_0</value></param>
<param><key>comment</key><value>Y Channel</value></param>
<param><key>header</key><value>5</value></param>
<param><key>notifyMissed</key><value>True</value></param>
<param><key>payloadsize</key><value>4160</value></param>
<param><key>port</key><value>50001</value></param>
</block>
<block>
<key>compress_compress</key>
<param><key>id</key><value>compress_compress_0</value></param>
<param><key>addheader</key><value>False</value></param>
<param><key>blocksize</key><value>64000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>numThreads</key><value>4</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>compress_compress</key>
<param><key>id</key><value>compress_compress_0_0</value></param>
<param><key>addheader</key><value>False</value></param>
<param><key>blocksize</key><value>64000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>numThreads</key><value>4</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>correctiq_SwapIQ</key>
<param><key>id</key><value>correctiq_SwapIQ_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>correctiq_SwapIQ</key>
<param><key>id</key><value>correctiq_SwapIQ_0_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>grnet_ByteComplexDecimator</key>
<param><key>id</key><value>grnet_ByteComplexDecimator_0</value></param>
<param><key>decimation</key><value>decimation</value></param>
</block>
<block>
<key>grnet_ByteComplexDecimator</key>
<param><key>id</key><value>grnet_ByteComplexDecimator_0_0</value></param>
<param><key>decimation</key><value>decimation</value></param>
</block>
<block>
<key>grnet_Signed8ToComplex</key>
<param><key>id</key><value>grnet_Signed8ToComplex_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>grnet_Signed8ToComplex</key>
<param><key>id</key><value>grnet_Signed8ToComplex_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>decimatedrate</value></param>
<param><key>fc</key><value>if_frequency</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>label1</key><value>X</value></param>
<param><key>label2</key><value>Y</value></param>
<param><key>name</key><value>Beamformer</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-100</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>tcp://*:50000</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0_0</value></param>
<param><key>address</key><value>tcp://*:50001</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>ata_ata_stream_0</source_block_id><sink_block_id>grnet_ByteComplexDecimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ata_ata_stream_0_0</source_block_id><sink_block_id>grnet_ByteComplexDecimator_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>compress_compress_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>compressed</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>compress_compress_0_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0_0</sink_block_id><source_key>compressed</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>correctiq_SwapIQ_0</source_block_id><sink_block_id>compress_compress_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correctiq_SwapIQ_0</source_block_id><sink_block_id>grnet_Signed8ToComplex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correctiq_SwapIQ_0_0</source_block_id><sink_block_id>compress_compress_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correctiq_SwapIQ_0_0</source_block_id><sink_block_id>grnet_Signed8ToComplex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_ByteComplexDecimator_0</source_block_id><sink_block_id>correctiq_SwapIQ_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_ByteComplexDecimator_0_0</source_block_id><sink_block_id>correctiq_SwapIQ_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_Signed8ToComplex_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_Signed8ToComplex_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
