<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>udp_record_data</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>local_listener_ip</value></param>
<param><key>value</key><value>'0.0.0.0'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>network_byte_rate</value></param>
<param><key>comment</key><value>MB/s on network</value></param>
<param><key>value</key><value>samp_rate*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>104e6</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>network_byte_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>filerepeater_AdvFileSink</key>
<param><key>id</key><value>filerepeater_AdvFileSink_0</value></param>
<param><key>autostartFreqChange</key><value>True</value></param>
<param><key>basedir</key><value>/media/root/18d6f16c-02e7-4056-9f85-042e4c546179/Recordings/ATA</value></param>
<param><key>basefile</key><value>ata_full</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>unbuffered</key><value>False</value></param>
<param><key>radioCenterFreq</key><value>0</value></param>
<param><key>honorFreqChange</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>maxSize</key><value>0</value></param>
<param><key>maxTimeSec</key><value>0</value></param>
<param><key>recordOnStart</key><value>True</value></param>
<param><key>sampleRate</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>grnet_udp_source</key>
<param><key>id</key><value>grnet_udp_source_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>port</key><value>50000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>filerepeater_AdvFileSink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_udp_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
