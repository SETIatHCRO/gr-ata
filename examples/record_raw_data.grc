options:
  parameters:
    generate_options: qt_gui
    id: usrp_2chrx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: fc
  id: parameter
  parameters:
    label: carrier frequency
    short_id: c
    type: eng_float
    value: 629e6
  states: {}
- name: file_channel_0
  id: blocks_file_sink
  parameters:
    file: src_name+'_'+timestamp+'.raw'
    type: complex
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '23'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 50e6
  states: {}
- name: src_name
  id: parameter
  parameters:
    type: str
    value: 2350+646
  states: {}
- name: timestamp
  id: parameter
  parameters:
    type: str
    value: str(datetime.now())
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: fc
    clock_rate: '0.0'
    clock_source0: internal
    dc_offs_enb0: 'False'
    dev_addr: '"serial=31D3A48"'
    dev_args: '""'
    gain0: gaindB
    iq_imbal_enb0: 'False'
    norm_gain0: 'False'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_conjugate_cc_0, '0', file_channel_0, '0']
- [blocks_conjugate_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source, '0', blocks_conjugate_cc_0, '0']

metadata:
  file_format: 1
