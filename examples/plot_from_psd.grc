options:
  parameters:
    author: ellie
    generate_options: qt_gui
    id: plotdata
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: c
  id: variable
  parameters:
    value: '300000000'
  states: {}
- name: cfreq
  id: variable
  parameters:
    value: '1420000000'
  states: {}
- name: fftsize
  id: variable
  parameters:
    comment: center frequency for voyager file
    value: 4096*4
  states: {}
- name: rest_freq
  id: variable
  parameters:
    value: '1420405752'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50000000/2
  states: {}
- name: v_corr
  id: variable
  parameters:
    value: v.vlsr_correction('2020-09-15T20:22:08', 5.575548, 22.014460)
  states: {}
- name: vmax
  id: variable
  parameters:
    value: c*(1 - (cfreq - (samp_rate)/2)/rest_freq)
  states: {}
- name: vmin
  id: variable
  parameters:
    value: c*(1 - (cfreq + (samp_rate)/2)/rest_freq)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ewhite/saga_spec_2020-09-16_035723.947956.dat
    repeat: 'True'
    type: float
    vlen: fftsize
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    vlen: fftsize
    x_axis_label: '"Freq"'
    x_start: cfreq - (samp_rate)
    x_step: 2*samp_rate/fftsize
    y_axis_label: '"Intensity"'
    ymax: '15'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: fftsize
    x_axis_label: '"V_LSR (km/s)"'
    x_start: (vmin/1000) - v_corr
    x_step: '-(vmax-vmin)/(fftsize*1000)'
    y_axis_label: '"Log PSD"'
    ymax: '0'
    ymin: '-25'
  states: {state: disabled}
- name: v
  id: epy_module
  parameters:
    source_code: "# Calculates the doppler shift of the HI line relative to the local standard of rest\n# Allows frequency shifting a signal to the V_LSR frame\n\n# Author: Paul Boven <p.boven@xs4all.nl>\n# Copyright (c) 2019 CAMRAS, released under CC BY v4.0\n# https://creativecommons.org/licenses/by/4.0/\n\n# Note: this requires GNU Radio 3.8 (or higher)\n# Required packages (Debian/Ubuntu): python3-zmq, python3-astropy\n\n# To communicate with GNU Radio\n\n'''Part of this code was adapted from a program written by Paul Boven of \n   Dwingeloo Observatory.\n\n   Note -- please give RA in hour angle format and Dec in decimal\n   degree format. (This is the ATA catalog default format).\n\n   E. White, 11 Aug. 2020\n'''\n\n# this module will be imported in the into your flowgraph\nfrom astropy import units as u\nfrom astropy.time import Time\nfrom astropy.coordinates import SkyCoord, EarthLocation, AltAz, get_sun\nimport time\n\n\ndef vlsr_correction(obs_timestamp, ra, dec):\n    # hcro\n    loc = EarthLocation.from_geodetic(lat=40.8172439*u.deg, \\\n                                      lon=-121.4698327*u.deg, \\\n                                      height=986.0*u.m)\n\n    # Correction for the Sun's motion in our own Galaxy\n    sun = get_sun(Time(obs_timestamp)).icrs\n    psun = SkyCoord(ra=\"18:03:50.29\", \\\n                    dec=\"+30:00:16.8\", \\\n                    frame=\"icrs\", unit=(u.hourangle, u.deg))\n    vsun = -20.0 * u.km / u.s\n\n    #Calculate the correction:\n    T = Time(obs_timestamp)\n\n    # Source (Antenna) Direction. Make sure to transform to icrs\n    SD = SkyCoord(ra=ra*u.hourangle, dec=dec*u.deg, frame='icrs', \\\n                  location = loc, obstime = T)\n\n    # Calculate radial velocity and correct for Solar motion\n    v = SD.cartesian.dot(psun.cartesian) * vsun - SD.radial_velocity_correction()\n\n    return v.value\n\n"
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_file_source_0, '0', qtgui_vector_sink_f_0_1, '0']

metadata:
  file_format: 1
