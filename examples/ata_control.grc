<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ata_control</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>25e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>throttle_rate</value></param>
<param><key>value</key><value>samp_rate*2</value></param>
</block>
<block>
<key>ata_atacontrol</key>
<param><key>id</key><value>ata_atacontrol_0</value></param>
<param><key>antenna</key><value>ant1</value></param>
<param><key>polling_sec</key><value>20</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>49601</value></param>
<param><key>tuning</key><value>a</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>baz_udp_source</key>
<param><key>id</key><value>baz_udp_source_0</value></param>
<param><key>borip</key><value>False</value></param>
<param><key>buf_size</key><value>0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>mode</key><value>2</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>wait</key><value>True</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>throttle_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>filerepeater_AdvFileSink</key>
<param><key>id</key><value>filerepeater_AdvFileSink_0</value></param>
<param><key>autostartFreqChange</key><value>True</value></param>
<param><key>basedir</key><value>/media/mpiscopo/536B035F2CBB251C/Recordings/ATA</value></param>
<param><key>basefile</key><value>ata</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>unbuffered</key><value>False</value></param>
<param><key>radioCenterFreq</key><value>0</value></param>
<param><key>honorFreqChange</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>maxSize</key><value>0</value></param>
<param><key>maxTimeSec</key><value>0</value></param>
<param><key>recordOnStart</key><value>False</value></param>
<param><key>sampleRate</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>filerepeater_MetaToPair</key>
<param><key>id</key><value>filerepeater_MetaToPair_0</value></param>
<param><key>keyin</key><value>az</value></param>
<param><key>keyout</key><value>az</value></param>
</block>
<block>
<key>filerepeater_MetaToPair</key>
<param><key>id</key><value>filerepeater_MetaToPair_0_0</value></param>
<param><key>keyin</key><value>el</value></param>
<param><key>keyout</key><value>el</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>key</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>float</value></param>
<param><key>value</key><value>2271e6</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0_0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>key</key><value>az</value></param>
<param><key>label</key><value>Target Azimuth</value></param>
<param><key>type</key><value>float</value></param>
<param><key>value</key><value>2271e6</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0_0_0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>key</key><value>el</value></param>
<param><key>label</key><value>Target Elevation</value></param>
<param><key>type</key><value>float</value></param>
<param><key>value</key><value>2271e6</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0_0_0_0</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>key</key><value>el</value></param>
<param><key>label</key><value>Current Elevation</value></param>
<param><key>type</key><value>float</value></param>
<param><key>value</key><value>2271e6</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0_0_1</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>key</key><value>az</value></param>
<param><key>label</key><value>Current Azimuth</value></param>
<param><key>type</key><value>float</value></param>
<param><key>value</key><value>2271e6</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,0,2,2</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>ata_atacontrol_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>freq</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>ata_atacontrol_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>freq</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>ata_atacontrol_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>status</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>ata_atacontrol_0</source_block_id><sink_block_id>filerepeater_MetaToPair_0</sink_block_id><source_key>status</source_key><sink_key>inmeta</sink_key></connection>
<connection><source_block_id>ata_atacontrol_0</source_block_id><sink_block_id>filerepeater_MetaToPair_0_0</sink_block_id><source_key>status</source_key><sink_key>inmeta</sink_key></connection>
<connection><source_block_id>baz_udp_source_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>baz_udp_source_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>filerepeater_AdvFileSink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>filerepeater_MetaToPair_0</source_block_id><sink_block_id>qtgui_edit_box_msg_0_0_1</sink_block_id><source_key>outpair</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>filerepeater_MetaToPair_0_0</source_block_id><sink_block_id>qtgui_edit_box_msg_0_0_0_0</sink_block_id><source_key>outpair</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0</source_block_id><sink_block_id>ata_atacontrol_0</sink_block_id><source_key>msg</source_key><sink_key>control</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>msg</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>msg</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>msg</source_key><sink_key>store</sink_key></connection>
</flow_graph>
