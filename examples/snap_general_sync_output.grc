options:
  parameters:
    author: ghostop14
    generate_options: no_gui
    id: snap_general_sync_output
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: ATA SNAP General Sync'd Output
  states: {}

blocks:
- name: ending_channel
  id: variable
  parameters:
    value: starting_channel+num_channels-1
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '256'
  states: {}
- name: snap_vector_len
  id: variable
  parameters:
    value: int((ending_channel-starting_channel+1)*2)
  states: {}
- name: starting_channel
  id: variable
  parameters:
    value: '1920'
  states: {}
- name: ata_SNAPSynchronizerV3_0
  id: ata_SNAPSynchronizerV3
  parameters:
    num_channels: num_channels
    num_inputs: '6'
  states: {}
- name: ata_snap_source_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap/snap_2_ant_1f.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'False'
    port: '10000'
    repeat_file: 'False'
    send_start_msg: 'False'
    starting_channel: starting_channel
    udp_ip: ''
  states: {}
- name: ata_snap_source_0_0
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap/snap_2_ant_1f.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'False'
    port: '10001'
    repeat_file: 'False'
    send_start_msg: 'False'
    starting_channel: starting_channel
    udp_ip: ''
  states: {}
- name: ata_snap_source_0_1
  id: ata_snap_source
  parameters:
    data_source: '1'
    ending_channel: ending_channel
    file: /home/sonata/casa_pcap/snap_2_ant_1f.pcap
    header: '1'
    ipv6: 'False'
    mcast_group: 224.1.1.10
    notifyMissed: 'True'
    packed_output: 'False'
    port: '10002'
    repeat_file: 'False'
    send_start_msg: 'False'
    starting_channel: starting_channel
    udp_ip: ''
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: source_10000.8bitiq_fft_256chan.x.iq
    type: byte
    vlen: snap_vector_len
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: source_10000.8bitiq_fft_256chan.y.iq
    type: byte
    vlen: snap_vector_len
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: source_10001.8bitiq_fft_256chan.y.iq
    type: byte
    vlen: snap_vector_len
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: source_10002.8bitiq_fft_256chan.y.iq
    type: byte
    vlen: snap_vector_len
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: source_10001.8bitiq_fft_256chan.x.iq
    type: byte
    vlen: snap_vector_len
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: source_10002.8bitiq_fft_256chan.x.iq
    type: byte
    vlen: snap_vector_len
  states: {}
- name: note_0
  id: note
  parameters:
    comment: These should be configured
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: These are calculated
  states: {}
- name: note_0_1
  id: note
  parameters:
    comment: |-
      The sync feedback disables tags (which impact performance) 
      when they're done being used for synchronization
  states: {}

connections:
- [ata_SNAPSynchronizerV3_0, '0', blocks_file_sink_0, '0']
- [ata_SNAPSynchronizerV3_0, '1', blocks_file_sink_0_0, '0']
- [ata_SNAPSynchronizerV3_0, '2', blocks_file_sink_0_1, '0']
- [ata_SNAPSynchronizerV3_0, '3', blocks_file_sink_0_0_0, '0']
- [ata_SNAPSynchronizerV3_0, '4', blocks_file_sink_0_2, '0']
- [ata_SNAPSynchronizerV3_0, '5', blocks_file_sink_0_0_1, '0']
- [ata_SNAPSynchronizerV3_0, sync, ata_snap_source_0, sync]
- [ata_SNAPSynchronizerV3_0, sync, ata_snap_source_0_0, sync]
- [ata_SNAPSynchronizerV3_0, sync, ata_snap_source_0_1, sync]
- [ata_snap_source_0, '0', ata_SNAPSynchronizerV3_0, '0']
- [ata_snap_source_0, '1', ata_SNAPSynchronizerV3_0, '1']
- [ata_snap_source_0_0, '0', ata_SNAPSynchronizerV3_0, '2']
- [ata_snap_source_0_0, '1', ata_SNAPSynchronizerV3_0, '3']
- [ata_snap_source_0_1, '0', ata_SNAPSynchronizerV3_0, '4']
- [ata_snap_source_0_1, '1', ata_SNAPSynchronizerV3_0, '5']

metadata:
  file_format: 1
