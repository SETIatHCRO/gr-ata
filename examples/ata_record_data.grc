<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ata_record_data</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>local_listener_ip</value></param>
<param><key>value</key><value>'0.0.0.0'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>network_byte_rate</value></param>
<param><key>comment</key><value>MB/s on network</value></param>
<param><key>value</key><value>samp_rate*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>104.8576e6</value></param>
</block>
<block>
<key>ata_ata_stream</key>
<param><key>id</key><value>ata_ata_stream_0</value></param>
<param><key>header</key><value>4</value></param>
<param><key>notifyMissed</key><value>False</value></param>
<param><key>payloadsize</key><value>4160</value></param>
<param><key>port</key><value>50000</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>filerepeater_AdvFileSink</key>
<param><key>id</key><value>filerepeater_AdvFileSink_0</value></param>
<param><key>autostartFreqChange</key><value>True</value></param>
<param><key>basedir</key><value>/opt/tmp/Recordings/ATA</value></param>
<param><key>basefile</key><value>ata</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>unbuffered</key><value>False</value></param>
<param><key>radioCenterFreq</key><value>0</value></param>
<param><key>honorFreqChange</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>maxSize</key><value>0</value></param>
<param><key>maxTimeSec</key><value>0</value></param>
<param><key>recordOnStart</key><value>False</value></param>
<param><key>sampleRate</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>ata_ata_stream_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ata_ata_stream_0</source_block_id><sink_block_id>filerepeater_AdvFileSink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
