options:
  parameters:
    author: ghostop14
    generate_options: no_gui
    id: ata_snap_xengine_offline_pipeline
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: ATA New SNAP X-Engine Offline Processing Pipeline
  states: {}

blocks:
- name: center_channel
  id: variable
  parameters:
    value: starting_channel + num_channels/2
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: sky_freq + (center_channel-2048)*channel_width
  states: {}
- name: channel_samp_rate
  id: variable
  parameters:
    value: snap_samp_rate*(num_channels/4096)
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: snap_samp_rate/4096.0
  states: {}
- name: data_vector_len
  id: variable
  parameters:
    value: int(snap_vector_len/2)
  states: {}
- name: ending_channel
  id: variable
  parameters:
    value: starting_channel+num_channels-1
  states: {}
- name: gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: half_channel_width
  id: variable
  parameters:
    value: channel_width/2.0
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: sky_freq
  id: variable
  parameters:
    value: 1690e6
  states: {}
- name: snap_samp_rate
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: snap_vector_len
  id: variable
  parameters:
    value: int((ending_channel-starting_channel+1)*2)
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: sky_freq - (2048-starting_channel)*channel_width
  states: {}
- name: starting_channel
  id: variable
  parameters:
    value: '1792'
  states: {}
- name: ata_snap_source_0
  id: ata_snap_source
  parameters:
    affinity: '1'
    ending_channel: ending_channel
    file: /mnt/ramdisk/goes17_volt_synced.rewrite_local.pcap
    header: '1'
    ipv6: 'False'
    notifyMissed: 'True'
    packed_output: 'False'
    port: '4030'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
    use_pcap: 'True'
  states: {}
- name: ata_snap_source_0_0
  id: ata_snap_source
  parameters:
    affinity: '2'
    ending_channel: ending_channel
    file: /mnt/ramdisk/goes17_volt_synced.rewrite_local_4031.pcap
    header: '1'
    ipv6: 'False'
    notifyMissed: 'True'
    packed_output: 'False'
    port: '4031'
    repeat_file: 'False'
    srcZeros: 'False'
    starting_channel: starting_channel
    use_pcap: 'True'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_char_to_complex_0_0_0_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/127.0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/127.0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/127.0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/127.0
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: byte
    vlen: num_channels*2
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
    vlen: num_channels*2
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: 500.0*2
    type: byte
    vlen: '2048'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_channels
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_channels
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_channels
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_channels
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: channel_samp_rate
    type: byte
    vlen: snap_vector_len
  states: {state: bypassed}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: snap_vector_len
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: snap_vector_len
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: snap_vector_len
    type: byte
  states: {}
- name: blocks_vector_to_stream_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: snap_vector_len
    type: byte
  states: {}
- name: clenabled_clXEngine_0
  id: clenabled_clXEngine
  parameters:
    affinity: '3'
    deviceId: '0'
    devices: '1'
    file_base: /opt/tmp/ata/xengine_output_ch1792-2815_xy_int1024_complex_input
    integration: '1024'
    num_channels: num_channels
    num_inputs: '2'
    openCLPlatform: '1'
    output_file: 'True'
    platformId: '0'
    polarization: '2'
    rollover_size_mb: '0'
    setDebug: 'False'
    type: Complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: These should be configured
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: These are calculated
  states: {}

connections:
- [ata_snap_source_0, '0', blocks_null_sink_0, '0']
- [ata_snap_source_0, '0', blocks_throttle_0, '0']
- [ata_snap_source_0, '1', blocks_null_sink_0, '1']
- [ata_snap_source_0, '1', blocks_vector_to_stream_0_0_0, '0']
- [ata_snap_source_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [ata_snap_source_0_0, '1', blocks_vector_to_stream_0_0_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_interleaved_char_to_complex_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', clenabled_clXEngine_0, '0']
- [blocks_stream_to_vector_0_0, '0', clenabled_clXEngine_0, '1']
- [blocks_stream_to_vector_0_0_0, '0', clenabled_clXEngine_0, '2']
- [blocks_stream_to_vector_0_0_0_0, '0', clenabled_clXEngine_0, '3']
- [blocks_throttle_0, '0', blocks_probe_rate_0, '0']
- [blocks_throttle_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_interleaved_char_to_complex_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_interleaved_char_to_complex_0_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', blocks_interleaved_char_to_complex_0_0_0_0_0, '0']

metadata:
  file_format: 1
