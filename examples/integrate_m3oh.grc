<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>integrate_m3oh</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>2048*4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>6669e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_center_freq</value></param>
<param><key>value</key><value>629.1456e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>104.8576e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>step_value</value></param>
<param><key>value</key><value>samp_rate/decimation/fftsize</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xstart_value</value></param>
<param><key>value</key><value>(freq-samp_rate/2/decimation)</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/opt/tmp/Recordings/ATA/M3OH_x_small_104.8576MSPS.bc</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>comment</key><value>This file is 56.09 seconds long</value></param>
<param><key>file</key><value>/media/mpiscopo/18d6f16c-02e7-4056-9f85-042e4c546179/Recordings/ATA/M3OH_x_104.8576MSPS.bc</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0</value></param>
<param><key>decim</key><value>1000</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>correctiq_correctiq_auto</key>
<param><key>id</key><value>correctiq_correctiq_auto_0</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>samp_rate</key><value>samp_rate/decimation</value></param>
<param><key>syncTime</key><value>5</value></param>
<param><key>gain</key><value>0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fftsize)</value></param>
</block>
<block>
<key>grnet_Signed8ToComplex</key>
<param><key>id</key><value>grnet_Signed8ToComplex_0</value></param>
</block>
<block>
<key>lfast_nlog10volk</key>
<param><key>id</key><value>lfast_nlog10volk_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>k</key><value>-30</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>lfast_nlog10volk</key>
<param><key>id</key><value>lfast_nlog10volk_1</value></param>
<param><key>comment</key><value>Normalized output will go 0 -&gt; -20 (0-100).  
So shift up 20 from the -30 scale.</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>k</key><value>-10</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>mesa_LongTermIntegrator</key>
<param><key>id</key><value>mesa_LongTermIntegrator_0</value></param>
<param><key>normalize</key><value>True</value></param>
<param><key>vlength</key><value>fftsize</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Elapsed Time</value></param>
<param><key>is_pair</key><value>False</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'0 seconds'</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decimation</value></param>
<param><key>fc</key><value>6669e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>name</key><value>Raw Signal</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-110</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>2,0,1,4</value></param>
<param><key>label1</key><value>M3(OH) Vertical Polarization</value></param>
<param><key>name</key><value>Vector Integration</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>x_axis_label</key><value>Frequency</value></param>
<param><key>x_start</key><value>xstart_value</value></param>
<param><key>x_step</key><value>step_value</value></param>
<param><key>x_units</key><value>Hz</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>10</value></param>
<param><key>y_axis_label</key><value>Power</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>3,0,1,4</value></param>
<param><key>label1</key><value>M3(OH) Vertical Polarization</value></param>
<param><key>name</key><value>Normalized Long-Term Integration</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>x_axis_label</key><value>Frequency</value></param>
<param><key>x_start</key><value>xstart_value</value></param>
<param><key>x_step</key><value>step_value</value></param>
<param><key>x_units</key><value>Hz</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>10</value></param>
<param><key>y_axis_label</key><value>Power</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_integrate_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>grnet_Signed8ToComplex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>grnet_Signed8ToComplex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0</source_block_id><sink_block_id>lfast_nlog10volk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0</source_block_id><sink_block_id>mesa_LongTermIntegrator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correctiq_correctiq_auto_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>correctiq_correctiq_auto_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_Signed8ToComplex_0</source_block_id><sink_block_id>pfb_decimator_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lfast_nlog10volk_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lfast_nlog10volk_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mesa_LongTermIntegrator_0</source_block_id><sink_block_id>lfast_nlog10volk_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mesa_LongTermIntegrator_0</source_block_id><sink_block_id>qtgui_edit_box_msg_0</sink_block_id><source_key>runtime</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>correctiq_correctiq_auto_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
